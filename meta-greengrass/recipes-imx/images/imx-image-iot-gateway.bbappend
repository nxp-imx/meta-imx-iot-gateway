IMAGE_INSTALL_append = " packagegroup-greengrass"
