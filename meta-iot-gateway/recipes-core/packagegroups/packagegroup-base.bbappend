RDEPENDS_packagegroup-base-wifi = "\
    iw \
    wireless-regdb-static \
    wpa-supplicant"
